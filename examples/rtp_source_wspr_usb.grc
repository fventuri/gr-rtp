options:
  parameters:
    author: Franco Venturi
    comment: |-
      Simple flowgraph to display the frequency spectrum for WSPR on 20m

      Below is the ka9q-radio radiod configuration file I used for this example.
      Note that the SDR hardware configuration section will likely have to be changed.


      IMPORTANT: check first with 'monitor wspr-pcm.local' to make sure there's audio on SSRC=14095600


      # WSPR on HF bands
      [global]
      status = wspr.local
      hardware = sdrplay

      [sdrplay]
      device = sdrplay
      description = RSPdx - Antenna C
      #serial =
      antenna = Antenna C
      #samprate = 2000000        ; default is 2M
      lna-state = 2
      if-agc = yes

      frequency = 14100000

      [WSPR]
      mode = usb
      data = wspr-pcm.local
      freq = "136k000 474k200 1m836600 3m592600 5m287200 7m038600 10m138700 14m095600 18m104600 21m094600 24m924600 28m124600"
    generate_options: qt_gui
    id: rtp_source_wspr_usb
    output_language: python
    title: RTP source - WSPR USB
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '12000'
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    average: '0.1'
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    freqhalf: 'False'
    type: float
  states: {}
- name: rtp_source_0
  id: rtp_source
  parameters:
    mcast_address: wspr-pcm.local
    output_mode: float-one-channel
    quiet: 'False'
    ssrc: '14095600'
  states: {}

connections:
- [rtp_source_0, '0', qtgui_freq_sink_x_0, '0']

metadata:
  file_format: 1
  grc_version: v3.11.0.0git-510-g2180acce
