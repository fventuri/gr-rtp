options:
  parameters:
    author: Franco Venturi
    comment: |-
      Simple flowgraph to listen to a NOAA radio stream from ka9q-radio

      Below is the ka9q-radio radiod configuration file I used for this example.
      Note that the SDR hardware configuration section will likely have to be changed.


      IMPORTANT: check first with 'monitor nws-pcm.local' to make sure there is audio on SSRC=162500
      (or one of the other SSRC's depending on your local NOAA radio channel)


      # Standard national weather service broadcasts
      [global]
      status = nws.local
      hardware = sdrplay

      [sdrplay]
      device = sdrplay
      description = RSPdx - Antenna C
      #serial =
      antenna = Antenna C
      #samprate = 2000000        ; default is 2M
      lna-state = 2
      if-agc = yes

      frequency = 162480000

      [NWS]
      mode = fm
      data = nws-pcm.local
      freq = "162m400 162m425 162m450 162m475 162m500 162m525 162m550"
    generate_options: no_gui
    generator_class_name: PythonNoGuiGenerator
    generator_module: gnuradio.grc.workflows.python_nogui
    id: rtp_source_nws_fm
    output_language: python
    title: RTP source - NOAA FM
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '24000'
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    samp_rate: samp_rate
  states: {}
- name: rtp_source_0
  id: rtp_source
  parameters:
    mcast_address: nws-pcm.local
    output_mode: float-one-channel
    quiet: 'False'
    ssrc: '162500'
  states: {}

connections:
- [rtp_source_0, '0', audio_sink_0, '0']

metadata:
  file_format: 1
  grc_version: v3.11.0.0git-1083-ge2c22a2b
