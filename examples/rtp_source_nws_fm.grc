options:
  parameters:
    author: Franco Venturi
    comment: |-
      Simple flowgraph to listen to a NOAA radio stream from ka9q-radio

      Below is the ka9q-radio radiod configuration file I used for this example.
      Note that that the input parameter will need to be changed.
      Also note that the ka9q-radio configuration has recently changed.

      IMPORTANT: check first with 'monitor nws-pcm.local' to make sure there's audio on SSRC=162550


      # Standard national weather service broadcasts
      [global]
      input = rspdx-antC.local
      iface = lo
      samprate = 24000
      mode = fm
      status = nws.local

      [NWS]
      data = nws-pcm.local
      freq = "162m400 162m425 162m450 162m475 162m500 162m525 162m550"
    generate_options: no_gui
    id: rtp_source_nws_fm
    output_language: python
    title: RTP source - NOAA FM
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '24000'
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    samp_rate: samp_rate
  states: {}
- name: rtp_source_0
  id: rtp_source
  parameters:
    mcast_address: nws-pcm.local
    output_mode: float-one-channel
    quiet: 'False'
    ssrc: '162550'
  states: {}

connections:
- [rtp_source_0, '0', audio_sink_0, '0']

metadata:
  file_format: 1
  grc_version: v3.11.0.0git-503-g35f8a0b3
