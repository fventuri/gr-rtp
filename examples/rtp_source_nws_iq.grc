options:
  parameters:
    author: Franco Venturi
    comment: |-
      Simple flowgraph to listen to a NOAA radio stream from ka9q-radio directly from the I/Q output

      Below is the ka9q-radio radiod configuration file I used for this example.
      Note that the SDR hardware configuration section will likely have to be changed.


      IMPORTANT: check first with 'monitor nws-iq-pcm.local' to make sure there is audio on SSRC=162550
      (or one of the other SSRC's depending on your local NOAA radio channel)


      # Standard national weather service broadcasts - I/Q stream
      [global]
      status = nws-iq.local
      hardware = sdrplay

      [sdrplay]
      device = sdrplay
      description = RSPdx - Antenna C
      #serial =
      antenna = Antenna C
      #samprate = 2000000        ; default is 2M
      lna-state = 2
      if-agc = yes

      frequency = 162480000

      [NWS-IQ]
      mode = iq
      data = nws-iq-pcm.local
      freq = 162m500
    generate_options: qt_gui
    generator_class_name: PythonQtGuiGenerator
    generator_module: gnuradio.grc.workflows.python_qt_gui
    id: rtp_source_nws_iq
    output_language: python
    title: RTP source - NOAA IQ->FM
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '12000'
  states: {}
- name: volume
  id: variable
  parameters:
    value: '0.5'
  states: {}
- name: analog_nbfm_rx_0
  id: analog_nbfm_rx
  parameters:
    audio_rate: samp_rate
    max_dev: 5e3
    quad_rate: samp_rate
    tau: '50e-6'
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    samp_rate: samp_rate
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: volume
    mode: vector
    type: float
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    average: '0.1'
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: complex
  states: {}
- name: rtp_source_0
  id: rtp_source
  parameters:
    mcast_address: nws-iq-pcm.local
    output_mode: gr_complex
    quiet: 'False'
    ssrc: '162500'
  states: {}

connections:
- [analog_nbfm_rx_0, '0', blocks_multiply_const_vxx_0, '0']
- [blocks_multiply_const_vxx_0, '0', audio_sink_0, '0']
- [rtp_source_0, '0', analog_nbfm_rx_0, '0']
- [rtp_source_0, '0', qtgui_freq_sink_x_0, '0']

metadata:
  file_format: 1
  grc_version: v3.11.0.0git-1083-ge2c22a2b
